# Autodesk Inventor part: Component1
Saved by Autodesk Inventor 2021.3 (Build 253353000, 353)
## iProperties
Created: 2022-05
Part Number: Component1
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Component1
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
